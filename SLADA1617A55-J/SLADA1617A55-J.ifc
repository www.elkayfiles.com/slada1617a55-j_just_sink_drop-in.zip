Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: Project Number
Time: 2023-08-18T11:44:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 18 11:44:27 2023 * Host: ZIL5CD2317NJM * Database: C:\Users\MKhan\AppData\Local\Temp\9fdc727d-aa43-461e-bb8c-5d133e642cb2\9f9da55c-20ce-4fb7-8591-c378dc75204a\ifc * Database version: 5507 * Database creation date: Fri Aug 18 11:44:26 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Aug 18 11:44:26 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 18 11:44:26 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 ft
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:1/4" Head, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_BuildingStoreyCommon - Reference: 1/4" Head

# IfcSanitaryTerminal: SLADA1617A55-J_Just_Sink_Drop-In:SLADA1617A55-J, SLADA1617A55-J_Just_Sink_Drop-In:SLADA1617A55-J:811838
In: Level 1
Type - Material: 304 Stainless Steel, Stainless Steel
Type - Pset_ElectricalDeviceCommon - InsulationStandardClass: n/a; IP_Code: n/a
Type - Pset_EnvironmentalImpactIndicators - Reference: SLADA1617A55-J
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - Manufacturer: www.justmfg.com
Type - Pset_SanitaryTerminalTypeCommon - Reference: SLADA1617A55-J; Color: 304 Stainless Steel
Material: Stainless Steel
